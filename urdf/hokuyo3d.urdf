Commit message: add assets_writer

File: urdf/hokuyo3d.urdf (robot description, URDF)
Before this commit: robot hokuyo3d, 3 links, 2 joints
Links:
- removed link laser_link
- added link hokuyo3d; visual cylinder length=0.07 radius=0.05
Joints:
- joint laser_link_joint: child laser_link -> hokuyo3d
